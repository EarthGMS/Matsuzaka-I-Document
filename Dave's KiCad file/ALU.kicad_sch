File: Dave's KiCad file/ALU.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Finalize the flag block (at least for now)
Other:
- note added: "L2 - flag block"
